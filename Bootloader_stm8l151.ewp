# IAR project Bootloader_stm8l151.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\IAR_PROJECT\Bootloader_stm8l151\STM8L15x_StdPeriph_Driver; E:\IAR_PROJECT\Bootloader_stm8l151\STM8L15x_StdPeriph_Driver\src; E:\IAR_PROJECT\Bootloader_stm8l151\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader_stm8l151_C8.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: E:\IAR_PROJECT\Bootloader_stm8l151\lnkstm8l151k6_BL_15092021.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group SPL
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_flash.c
